Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:08+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SPH-T-02
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-SPH-T-02 Полусфера 400×200 · цветной бетон «Терракота»
In: Площадка
Description: Изделие бетонное благоустройства. Полусфера 400×200 · цветной бетон «Терракота»; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон (белый портландцемент + пигмент в массе)
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SPH-T-02; ModelReference: Полусфера 400×200 · цветной бетон «Терракота»; ProductionYear: 2026; ArticleNumber: ZSK-SPH-T-02
ORION_Изделие - Артикул: ZSK-SPH-T-02; Артикул прежний: SD-SPH-T-02; Наименование: Полусфера 400×200 · цветной бетон «Терракота»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: ⌀400 мм · высота 200 мм; Материал: Бетон (белый портландцемент + пигмент в массе); Цена: 10 400 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20203; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Полусфера 400×200 · цветной бетон «Терракота»; ADSK_Марка: ZSK-SPH-T-02; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон (белый портландцемент + пигмент в массе); ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20203
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-SPH-T-02
Qto_ORION - Длина: 400 mm; Ширина: 400 mm; Высота: 200 mm
